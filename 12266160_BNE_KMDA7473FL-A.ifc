Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: ea48f312-719c-414a-90ec-42a3aa3396e9, NumberOfSaves: 1]
File name: 0001
Time: 2024-09-10T09:51:58+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12266160_BNE_KMDA7473FL-A:26747378_BNE_12266160_KMDA7473FL-A, (2)
In: Default
Type - Material: z_Miele_Design_CLST, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_OBSW
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 800 mm; Height: 200 mm; Depth: 520 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 26747378_BNE_12266160_KMDA7473FL-A; sets with these values: 2
